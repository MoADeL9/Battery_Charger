# Repository MoADeL9/Battery_Charger

## KiCad design Battery_Charger.kicad_pcb

Parts:
C1, C2: 4.7uF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
D1: LED; LED_1206_3216Metric_Pad1.42x1.75mm_HandSolder
J1: USB_B_Micro; USB_Micro-B_Molex-105017-0001
J2: Conn_01x02; JST_GH_SM02B-GHS-TB_1x02-1MP_P1.25mm_Horizontal
R1: 470R; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R2: 2k; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
U1: MCP73831-2-OT; SOT-23-5

Connections:
GND: C1.2, C2.2, J1.5 (GND), J1.6 (Shield), J2.2, R2.2, U1.2 (VSS)
unnamed: D1.1 (K), R1.1
unnamed: R2.1, U1.5 (PROG)
unnamed: R1.2, U1.1 (STAT)
VBUS: C1.1, D1.2 (A), J1.1 (VBUS), U1.4 (VDD)
VCC: C2.1, J2.1, U1.3 (VBAT)

Notes on the sheet:
IMT_SCHOOL
Process
Micro USB to supply charge
OUTPUT
Battery connecctor
INPUT
MCP73831-2-OT Battery charging circuit

Board: 2 copper layers, 16.5 x 25.6 mm, 8 parts (0 on the bottom side), 6 nets.

## Commit log

2025-03-07 moved the track
2025-03-07 deleted a backup file
2025-03-07 Removed copper fill....
2025-03-07 modified .Kicad_prl
2025-03-07 Added copper fill
